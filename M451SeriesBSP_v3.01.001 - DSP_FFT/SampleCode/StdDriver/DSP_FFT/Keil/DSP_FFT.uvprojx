# Keil uVision project DSP_FFT.uvprojx, settings and files
target DSP_FFT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: DSP_FFT
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SystemConfig\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group User
    ../User/src/: main.c
  group StdDriver
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c analog.c eadc.c pwm.c
  group Lib
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group SystemConfig
    ../../../../Library/SystemConfig/src/: GPIOConfig.c SystemConfig.c
software components: CMSIS:CORE 5.0.1
